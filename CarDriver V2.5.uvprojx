# Keil uVision project CarDriver V2.5.uvprojx, settings and files
target CarDriver (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C1290NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WHUCAR Driver V2.4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C1290NCPDT TARGET_IS_TM4C129_RA0
  c misc: --c99
  c include: ./;./inc;./driverlib;./Core/Inc;./BSP/Inc;./third_party/FreeRTOS/Source/include;./third_party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;./MCU_Develop_Package;./CMSIS/Core/Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Core
    ./Core/Src/: main.c tm4c129_it.c tv_gpio.c tv_i2c.c tv_uart.c tv_pwm.c freertos.c tv_dma.c tv_adc.c i2cm_drv.c
  group Libarary
    ./driverlib/: adc.c gpio.c i2c.c interrupt.c pwm.c uart.c sysctl.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c hibernate.c lcd.c mpu.c onewire.c qei.c shamd5.c ssi.c sw_crc.c sysexc.c systick.c timer.c udma.c usb.c watchdog.c
  group Startup
    ./: startup_rvmdk.S
  group FreeRTOS
    ./third_party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./third_party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ./third_party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group BSP
    ./BSP/Src/: motor.c 4wheel_differential.c icm20602.c mdp_io.c mdp_pkgproc.c servo.c tf_luna.c oled.c
